/dts-v1/;

/ {
	compatible = "SAMSUNG", " A21S_EUR_OPEN", " EXYNOS850";
	dtbo-hw_rev = <0x03>;
	dtbo-hw_rev_end = <0x05>;

	fragment@smd {
		target-path = [2f 00];

		__overlay__ {

			samsung_mobile_device {
				compatible = "simple-bus";
				phandle = <0x4e>;

				sec_abc {
					compatible = "samsung,sec_abc";
					status = "okay";

					gpu {
						gpu,label = "GPU fault";
						gpu,threshold_count = <0x14>;
						gpu,threshold_time = <0x4b0>;
					};

					aicl {
						aicl,label = "battery aicl";
						aicl,threshold_count = <0x05>;
						aicl,threshold_time = <0x12c>;
					};
				};

				abc_hub {
					compatible = "samsung,abc_hub";
					status = "okay";

					bootc {
						bootc,time_spec_user = <0x186a0>;
						bootc,time_spec_eng = <0x186a0>;
						bootc,time_spec_fac = <0x186a0>;
					};
				};

				sec_thermistor@0 {
					compatible = "samsung,sec-thermistor";
					status = "okay";
					thermistor_name = "sec-ap-thermistor";
					id = <0x00>;
					io-channels = <0xffffffff 0x00>;
					io-channel-names = "ap_therm";
					io-channel-ranges;
					adc_array = <0x10f 0x141 0x17e 0x1c4 0x214 0x271 0x2de 0x360 0x3eb 0x495 0x54b 0x616 0x6ed 0x7d3 0x8bd 0x9a7 0xa89 0xb60 0xc1d 0xcd4 0xd6e 0xddb 0xe4b>;
					temp_array = <0x384 0x352 0x320 0x2ee 0x2bc 0x28a 0x258 0x226 0x1f4 0x1c2 0x190 0x15e 0x12c 0xfa 0xc8 0x96 0x64 0x32 0x00 0xffffffce 0xffffff9c 0xffffff6a 0xffffff38>;
					phandle = <0x4f>;
				};

				muic {
					new_factory;
					dcd_timeout;
				};

				etspi-spi@0 {
					compatible = "etspi,et5xx";
					reg = <0x00>;
					spi-max-frequency = <0xbebc20>;
					clocks = <0xffffffff 0x239 0xffffffff 0x23d>;
					clock-names = "gate_spi_clk", "ipclk_spi";
					pinctrl-names = "default", "pins_poweron", "pins_poweroff", "pins_poweron_tz", "pins_poweroff_tz";
					pinctrl-0 = <0x01 0x02>;
					pinctrl-1 = <0x03 0x04 0x05 0x06 0x07>;
					pinctrl-2 = <0x01 0x08 0x09>;
					pinctrl-3 = <0x03>;
					pinctrl-4 = <0x01>;
					gpio-controller;
					#gpio-cells = <0x02>;
					etspi-sleepPin = <0xffffffff 0x01 0x00>;
					etspi-drdyPin = <0xffffffff 0x05 0x00>;
					etspi-regulator = "VDD_BTP_3P3";
					etspi-chipid = "ET520";
					etspi-orient = <0x01>;

					controller-data {
						cs-gpio = <0xffffffff 0x01 0x00>;
						samsung,spi-feedback-delay = <0x00>;
						samsung,spi-chip-select-mode = <0x00>;
					};
				};

				battery_params {
					battery,battery_data = <0xf8 0x0a 0x75 0x0a 0xf2 0x09 0x80 0x09 0x13 0x09 0xab 0x08 0x49 0x08 0xd0 0x07 0x9c 0x07 0x46 0x07 0xe6 0x06 0xac 0x06 0x82 0x06 0x61 0x06 0x47 0x06 0x2d 0x06 0x07 0x06 0xdf 0x05 0x9b 0x05 0x82 0x05 0x98 0x04 0x9c 0x01 0x6a 0x08 0x00 0x08 0x96 0x07 0x2c 0x07 0xc2 0x06 0x58 0x06 0xee 0x05 0x84 0x05 0x1a 0x05 0xb1 0x04 0x47 0x04 0xdd 0x03 0x73 0x03 0x09 0x03 0x9f 0x02 0x35 0x02 0xcb 0x01 0x61 0x01 0xf7 0x00 0x8d 0x00 0x23 0x00 0xe3 0x0f 0x0a 0x0a 0x0a 0x0a 0x33 0x33 0x33 0x34 0x33 0x33 0x33 0x33 0x34 0x34 0x34 0x35 0x36 0x37 0x39 0x3c 0x41 0x9a 0xc4 0x49 0xc0 0x0e 0x00 0x08 0x2915 0x2710 0x250b 0x2306 0x2100 0x1efb 0x1cf6 0x1af1 0x18eb 0x16e6 0x14e1 0x12dc 0x10d6 0xed1 0xccc 0xac7 0x8c1 0x6bc 0x4b7 0x2b2 0xac 0xffffff73 0xaabf 0xa83f 0xa5be 0xa391 0xa180 0x9f85 0x9da3 0x9b58 0x9a59 0x98b3 0x96e1 0x95c2 0x94f5 0x9454 0x93d6 0x9359 0x929d 0x91d8 0x908f 0x9014 0x8ba0 0x7d0e 0x00 0xe9 0x0a 0x6c 0x0a 0xef 0x09 0x7b 0x09 0x0b 0x09 0xa2 0x08 0x3e 0x08 0xe5 0x07 0x96 0x07 0x23 0x07 0xd8 0x06 0xa6 0x06 0x7e 0x06 0x5e 0x06 0x44 0x06 0x24 0x06 0xfa 0x05 0xc9 0x05 0x8b 0x05 0x78 0x05 0x62 0x03 0x5a 0x01 0x76 0x08 0x0b 0x08 0x9f 0x07 0x33 0x07 0xc7 0x06 0x5c 0x06 0xf0 0x05 0x84 0x05 0x18 0x05 0xad 0x04 0x41 0x04 0xd5 0x03 0x69 0x03 0xfe 0x02 0x92 0x02 0x26 0x02 0xba 0x01 0x4f 0x01 0xe3 0x00 0x77 0x00 0x0b 0x00 0x88 0x0f 0x0a 0x0a 0x0a 0x0a 0x36 0x36 0x36 0x36 0x36 0x36 0x36 0x36 0x37 0x37 0x38 0x38 0x38 0x39 0x3b 0x3f 0x4c 0x65 0x5c 0x4b 0x12 0x0f 0x00 0x08 0x2952 0x2744 0x2535 0x2327 0x2119 0x1f0b 0x1cfd 0x1aef 0x18e1 0x16d2 0x14c4 0x12b6 0x10a8 0xe9a 0xc8c 0xa7e 0x870 0x661 0x453 0x245 0x37 0xfffffdb8 0xaa76 0xa814 0xa5b3 0xa379 0xa159 0x9f55 0x9d6e 0x9bbd 0x9a38 0x980b 0x969d 0x95a7 0x94e3 0x9447 0x93c6 0x932a 0x9260 0x9171 0x9041 0x8fe5 0x85b5 0x7bcb 0x00 0xe9 0x0a 0x6c 0x0a 0xef 0x09 0x7b 0x09 0x0b 0x09 0xa2 0x08 0x3e 0x08 0xe5 0x07 0x96 0x07 0x23 0x07 0xd8 0x06 0xa6 0x06 0x7e 0x06 0x5e 0x06 0x44 0x06 0x24 0x06 0xfa 0x05 0xc9 0x05 0x8b 0x05 0x78 0x05 0x62 0x03 0x5a 0x01 0x9f 0x08 0x31 0x08 0xc3 0x07 0x55 0x07 0xe8 0x06 0x7a 0x06 0x0c 0x06 0x9e 0x05 0x31 0x05 0xc3 0x04 0x55 0x04 0xe7 0x03 0x7a 0x03 0x0c 0x03 0x9e 0x02 0x30 0x02 0xc3 0x01 0x55 0x01 0xe7 0x00 0x79 0x00 0x0c 0x00 0x88 0x0f 0x0a 0x0a 0x0a 0x0a 0x36 0x36 0x36 0x36 0x36 0x36 0x36 0x36 0x37 0x37 0x38 0x38 0x38 0x39 0x3b 0x3f 0x4c 0x65 0xf8 0x49 0xcb 0x0e 0x00 0x08 0x2a16 0x27fe 0x25e6 0x23ce 0x21b6 0x1f9e 0x1d87 0x1b6f 0x1957 0x173f 0x1527 0x130f 0x10f7 0xedf 0xcc7 0xab0 0x898 0x680 0x468 0x250 0x38 0xfffffdb6 0xaa76 0xa814 0xa5b3 0xa379 0xa159 0x9f55 0x9d6e 0x9bbd 0x9a38 0x980b 0x969d 0x95a7 0x94e3 0x9447 0x93c6 0x932a 0x9260 0x9171 0x9041 0x8fe5 0x85b5 0x7bcb 0x00 0xe9 0x0a 0x6c 0x0a 0xef 0x09 0x7b 0x09 0x0b 0x09 0xa2 0x08 0x3e 0x08 0xe5 0x07 0x96 0x07 0x23 0x07 0xd8 0x06 0xa6 0x06 0x7e 0x06 0x5e 0x06 0x44 0x06 0x24 0x06 0xfa 0x05 0xc9 0x05 0x8b 0x05 0x78 0x05 0x62 0x03 0x5a 0x01 0xcb 0x08 0x5b 0x08 0xeb 0x07 0x7b 0x07 0x0b 0x07 0x9b 0x06 0x2b 0x06 0xbb 0x05 0x4b 0x05 0xdb 0x04 0x6b 0x04 0xfb 0x03 0x8b 0x03 0x1b 0x03 0xab 0x02 0x3c 0x02 0xcc 0x01 0x5c 0x01 0xec 0x00 0x7c 0x00 0x0c 0x00 0x88 0x0f 0x0a 0x0a 0x0a 0x0a 0x36 0x36 0x36 0x36 0x36 0x36 0x36 0x36 0x37 0x37 0x38 0x38 0x38 0x39 0x3b 0x3f 0x4c 0x65 0x84 0x48 0x80 0x0e 0x00 0x08 0x2aee 0x28cb 0x26a9 0x2486 0x2263 0x2041 0x1e1e 0x1bfb 0x19d9 0x17b6 0x1594 0x1371 0x114e 0xf2c 0xd09 0xae6 0x8c4 0x6a1 0x47e 0x25c 0x39 0xfffffdb4 0xaa76 0xa814 0xa5b3 0xa379 0xa159 0x9f55 0x9d6e 0x9bbd 0x9a38 0x980b 0x969d 0x95a7 0x94e3 0x9447 0x93c6 0x932a 0x9260 0x9171 0x9041 0x8fe5 0x85b5 0x7bcb 0x00 0xe9 0x0a 0x6c 0x0a 0xef 0x09 0x7b 0x09 0x0b 0x09 0xa2 0x08 0x3e 0x08 0xe5 0x07 0x96 0x07 0x23 0x07 0xd8 0x06 0xa6 0x06 0x7e 0x06 0x5e 0x06 0x44 0x06 0x24 0x06 0xfa 0x05 0xc9 0x05 0x8b 0x05 0x78 0x05 0x62 0x03 0x5a 0x01 0x36 0x09 0xc0 0x08 0x4b 0x08 0xd6 0x07 0x61 0x07 0xeb 0x06 0x76 0x06 0x01 0x06 0x8b 0x05 0x16 0x05 0xa1 0x04 0x2c 0x04 0xb6 0x03 0x41 0x03 0xcc 0x02 0x57 0x02 0xe1 0x01 0x6c 0x01 0xf7 0x00 0x82 0x00 0x0c 0x00 0x88 0x0f 0x0a 0x0a 0x0a 0x0a 0x36 0x36 0x36 0x36 0x36 0x36 0x36 0x36 0x37 0x37 0x38 0x38 0x38 0x39 0x3b 0x3f 0x4c 0x65 0x3c 0x45 0xd8 0x0d 0x00 0x08 0x2cf7 0x2abb 0x287e 0x2641 0x2405 0x21c8 0x1f8c 0x1d4f 0x1b13 0x18d6 0x169a 0x145d 0x1220 0xfe4 0xda7 0xb6b 0x92e 0x6f2 0x4b5 0x278 0x3c 0xfffffdb0 0xaa76 0xa814 0xa5b3 0xa379 0xa159 0x9f55 0x9d6e 0x9bbd 0x9a38 0x980b 0x969d 0x95a7 0x94e3 0x9447 0x93c6 0x932a 0x9260 0x9171 0x9041 0x8fe5 0x85b5 0x7bcb 0x00>;
					phandle = <0x50>;
				};

				battery {
					battery,fuelgauge_name = "s2mu106-fuelgauge";
					battery,fgsrc_switch_name = "s2mu106-fuelgauge";
					status = "okay";
					compatible = "samsung,sec-battery";
					battery,vendor = "Battery";
					battery,charger_name = "s2mu106-charger";
					battery,technology = <0x02>;
					battery,batt_data_version = <0x01>;
					battery,temp_adc_type = <0x01>;
					battery,adc_check_count = <0x05>;
					battery,temp_check_type = <0x02>;
					battery,usb_temp_check_type = <0x00>;
					battery,chg_temp_check_type = <0x02>;
					battery,wpc_temp_check_type = <0x00>;
					battery,thermal_source = <0x02>;
					battery,usb_thermal_source = <0x05>;
					battery,chg_thermal_source = <0x00>;
					battery,wpc_thermal_source = <0x05>;
					battery,polling_time = <0x0a 0x1e 0x1e 0x1e 0xe10>;
					battery,cable_check_type = <0x04>;
					battery,cable_source_type = <0x01>;
					battery,polling_type = <0x01>;
					battery,monitor_initial_count = <0x00>;
					battery,battery_check_type = <0x00>;
					battery,ovp_uvlo_check_type = <0x03>;
					battery,temp_check_count = <0x01>;
					battery,temp_highlimit_threshold_event = <0x320>;
					battery,temp_highlimit_recovery_event = <0x30c>;
					battery,temp_high_threshold_event = <0x1f4>;
					battery,temp_high_recovery_event = <0x1e0>;
					battery,temp_low_threshold_event = <0x00>;
					battery,temp_low_recovery_event = <0x14>;
					battery,temp_highlimit_threshold_normal = <0x320>;
					battery,temp_highlimit_recovery_normal = <0x30c>;
					battery,temp_high_threshold_normal = <0x1f4>;
					battery,temp_high_recovery_normal = <0x1e0>;
					battery,temp_low_threshold_normal = <0x00>;
					battery,temp_low_recovery_normal = <0x14>;
					battery,temp_highlimit_threshold_lpm = <0x320>;
					battery,temp_highlimit_recovery_lpm = <0x30c>;
					battery,temp_high_threshold_lpm = <0x1f4>;
					battery,temp_high_recovery_lpm = <0x1e0>;
					battery,temp_low_threshold_lpm = <0x00>;
					battery,temp_low_recovery_lpm = <0x14>;
					battery,wpc_high_threshold_normal = <0x1c2>;
					battery,wpc_high_recovery_normal = <0x1ae>;
					battery,wpc_low_threshold_normal = <0x00>;
					battery,wpc_low_recovery_normal = <0x14>;
					battery,full_check_type = <0x02>;
					battery,full_check_type_2nd = <0x02>;
					battery,full_check_count = <0x01>;
					battery,chg_gpio_full_check = <0x00>;
					battery,chg_polarity_full_check = <0x01>;
					battery,chg_high_temp = <0x1f4>;
					battery,chg_high_temp_recovery = <0x1e0>;
					battery,chg_input_limit_current = <0x3e8>;
					battery,chg_charging_limit_current = <0x578>;
					battery,wpc_temp_control_source = <0x01>;
					battery,wpc_high_temp = <0x17c>;
					battery,wpc_high_temp_recovery = <0x168>;
					battery,wpc_input_limit_current = <0x258>;
					battery,wpc_charging_limit_current = <0x3e8>;
					battery,wpc_temp_lcd_on_control_source = <0x01>;
					battery,wpc_lcd_on_high_temp = <0x17c>;
					battery,wpc_lcd_on_high_temp_rec = <0x168>;
					battery,wpc_lcd_on_input_limit_current = <0x1c2>;
					battery,wpc_store_high_temp = <0x168>;
					battery,wpc_store_high_temp_recovery = <0x154>;
					battery,wpc_store_charging_limit_current = <0x190>;
					battery,wpc_store_lcd_on_high_temp = <0x168>;
					battery,wpc_store_lcd_on_high_temp_rec = <0x12c>;
					battery,wpc_store_lcd_on_charging_limit_current = <0x190>;
					battery,sleep_mode_limit_current = <0x1f4>;
					battery,wc_full_input_limit_current = <0x64>;
					battery,mix_high_temp = <0x1a4>;
					battery,mix_high_chg_temp = <0x1f4>;
					battery,mix_high_temp_recovery = <0x186>;
					battery,full_condition_type = <0x09>;
					battery,full_condition_soc = <0x5d>;
					battery,full_condition_vcell = <0x109a>;
					battery,recharge_check_count = <0x01>;
					battery,recharge_condition_type = <0x04>;
					battery,recharge_condition_soc = <0x62>;
					battery,recharge_condition_vcell = <0x10b8>;
					battery,charging_total_time = <0x3840>;
					battery,hv_charging_total_time = <0x2a30>;
					battery,normal_charging_total_time = <0x4650>;
					battery,usb_charging_total_time = <0x8ca0>;
					battery,recharging_total_time = <0x1518>;
					battery,charging_reset_time = <0x00>;
					battery,chg_float_voltage = <0x10fe>;
					battery,pre_afc_work_delay = <0x7d0>;
					battery,pre_wc_afc_work_delay = <0xfa0>;
					battery,pre_afc_input_current = <0x1f4>;
					battery,pre_wc_afc_input_current = <0x1f4>;
					battery,prepare_ta_delay = <0x00>;
					battery,swelling_high_temp_block = <0x19a>;
					battery,swelling_high_temp_recov = <0x186>;
					battery,swelling_low_temp_block_1st = <0x96>;
					battery,swelling_low_temp_recov_1st = <0xaa>;
					battery,swelling_low_temp_block_2nd = <0x32>;
					battery,swelling_low_temp_recov_2nd = <0x46>;
					battery,swelling_drop_float_voltage = <0x1036>;
					battery,swelling_high_rechg_voltage = <0xfa0>;
					battery,swelling_low_rechg_voltage = <0x1068>;
					battery,siop_input_limit_current = <0x4b0>;
					battery,siop_charging_limit_current = <0x3e8>;
					battery,siop_hv_input_limit_current = <0x2bc>;
					battery,siop_hv_input_limit_current_2nd = <0x226>;
					battery,siop_hv_charging_limit_current = <0x3e8>;
					battery,rp_current_rp1 = <0x1f4>;
					battery,rp_current_rp2 = <0x5dc>;
					battery,rp_current_rp3 = <0xbb8>;
					battery,rp_current_rdu_rp3 = <0x834>;
					battery,rp_current_abnormal_rp3 = <0x708>;
					battery,pd_charging_charge_power = <0x3a98>;
					battery,max_charging_current = <0x960>;
					battery,store_mode_charging_max = <0x46>;
					battery,store_mode_charging_min = <0x3c>;
					battery,wireless_cc_cv = <0x55>;
					battery,wireless_otg_input_current = <0x384>;
					battery,age_data = <0x00 0x10fe 0x10b8 0x109a 0x5d 0x12c 0x10ea 0x10a4 0x1086 0x5c 0x190 0x10d6 0x1090 0x1072 0x5b 0x2bc 0x10c2 0x107c 0x105e 0x5a 0x3e8 0x1090 0x104a 0x102c 0x59>;
					battery,max_input_voltage = <0x2328>;
					battery,max_input_current = <0xbb8>;
					battery,cisd_alg_index = <0x08>;
					battery,cisd_max_voltage_thr = <0x1388>;
					battery,ignore_cisd_index = <0x00 0x00>;
					battery,ignore_cisd_index_d = <0x00 0x50>;
					battery,expired_time = <0x35e8>;
					battery,recharging_expired_time = <0x1518>;
					battery,battery_full_capacity = <0x1388>;
					io-channels = <0xffffffff 0x01>;
					io-channel-names = "adc-temp", "n/a", "n/a", "n/a", "n/a";
					pinctrl-names = "default";
					battery,chip_vendor = "LSI";
					battery,temp_table_adc = <0x137 0x15d 0x193 0x1de 0x235 0x29e 0x30d 0x38e 0x417 0x4c4 0x566 0x64f 0x731 0x80b 0x8ed 0x9c3 0xabb 0xb86 0xc57 0xceb 0xd93 0xe14 0xe6a>;
					battery,temp_table_data = <0x384 0x352 0x320 0x2ee 0x2bc 0x28a 0x258 0x226 0x1f4 0x1c2 0x190 0x15e 0x12c 0xfa 0xc8 0x96 0x64 0x32 0x00 0xffffffce 0xffffff9c 0xffffff6a 0xffffff38>;
					battery,overheatlimit_threshold = <0x2bc>;
					battery,overheatlimit_recovery = <0x2a8>;
					battery,usb_protection_temp = <0x262>;
					battery,temp_gap_bat_usb = <0xc8>;
					battery,wire_warm_overheat_thresh = <0x1f4>;
					battery,wire_normal_warm_thresh = <0x19a>;
					battery,wire_cool1_normal_thresh = <0x96>;
					battery,wire_cool2_cool1_thresh = <0x96>;
					battery,wire_cool3_cool2_thresh = <0x32>;
					battery,wire_cold_cool3_thresh = <0x00>;
					battery,wireless_warm_overheat_thresh = <0x1c2>;
					battery,wireless_normal_warm_thresh = <0x19a>;
					battery,wireless_cool1_normal_thresh = <0x96>;
					battery,wireless_cool2_cool1_thresh = <0x96>;
					battery,wireless_cool3_cool2_thresh = <0x32>;
					battery,wireless_cold_cool3_thresh = <0x00>;
					battery,wire_warm_current = <0x514>;
					battery,wire_cool1_current = <0x960>;
					battery,wire_cool2_current = <0x352>;
					battery,wire_cool3_current = <0x1c2>;
					battery,wireless_warm_current = <0x352>;
					battery,wireless_cool1_current = <0x960>;
					battery,wireless_cool2_current = <0x352>;
					battery,wireless_cool3_current = <0x1c2>;
					battery,high_temp_topoff = <0xfa>;
					battery,low_temp_topoff = <0xfa>;
					battery,high_temp_float = <0x1036>;
					battery,low_temp_float = <0x10fe>;
					battery,siop_event_check_type = <0x01>;
					battery,siop_call_cv_current = <0x14a>;
					battery,siop_call_cc_current = <0x14a>;
					battery,siop_apdo_input_limit_current = <0x4b0>;
					battery,siop_apdo_charging_limit_current = <0x7d0>;
					battery,max_charging_charge_power = <0x3a98>;
					battery,health_condition = <0x384 0x00 0x4b0 0x00 0x5dc 0x00>;
					battery,enable_sysovlo_irq;
					battery,enable_noise_wa;
					battery,standard_curr = <0x960>;
					battery,ttf_hv_charge_current = <0x898>;
					battery,ttf_capacity = <0xfa0>;
					battery,cv_data = <0x911 0x360 0x8d3 0x8b2 0x368 0x897 0x822 0x370 0x85a 0x771 0x37c 0x7ff 0x6e5 0x385 0x7a5 0x646 0x38f 0x741 0x5c2 0x399 0x6d2 0x526 0x3a4 0x65a 0x4a1 0x3ac 0x5d7 0x411 0x3b6 0x540 0x35d 0x3c0 0x48c 0x2ea 0x3ca 0x294 0x261 0x3d4 0x1e0 0x1f9 0x3de 0x3c 0x1d6 0x3e8 0x00>;
					phandle = <0x51>;
				};

				s2mu106-charger {
					status = "disable";
					compatible = "samsung,s2mu106-charger";
					charger,mrstbtmr_factory = <0x01>;
					phandle = <0x52>;
				};

				cable-info {
					default_input_current = <0x708>;
					default_charging_current = <0x834>;
					full_check_current_1st = <0x1f4>;
					full_check_current_2nd = <0xfa>;
					phandle = <0x53>;

					current_group_1 {
						cable_number = <0x02 0x13 0x15 0x16 0x17>;
						input_current = <0x1f4>;
						charging_current = <0x1f4>;
					};

					current_group_2 {
						cable_number = <0x19 0x1f>;
						input_current = <0x3e8>;
						charging_current = <0x3e8>;
					};

					current_group_3 {
						cable_number = <0x05 0x20>;
						input_current = <0x5dc>;
						charging_current = <0x5dc>;
					};

					current_group_4 {
						cable_number = <0x06 0x07 0x08 0x11 0x12 0x28>;
						input_current = <0x672>;
						charging_current = <0x960>;
					};

					current_group_5 {
						cable_number = <0x09>;
						input_current = <0x672>;
						charging_current = <0x960>;
					};

					current_group_6 {
						cable_number = <0x0a 0x0c 0x0f 0x1b 0x21 0x24>;
						input_current = <0x320>;
						charging_current = <0x960>;
					};

					current_group_7 {
						cable_number = <0x0d>;
						input_current = <0x2bc>;
						charging_current = <0x960>;
					};

					current_group_8 {
						cable_number = <0x18>;
						input_current = <0x3e8>;
						charging_current = <0x1c2>;
					};

					current_group_9 {
						cable_number = <0x1a>;
						input_current = <0x708>;
						charging_current = <0x708>;
					};

					current_group_10 {
						cable_number = <0x0b 0x0e 0x10 0x1c 0x23>;
						input_current = <0x28a>;
						charging_current = <0x960>;
					};

					current_group_11 {
						cable_number = <0x1d 0x25>;
						input_current = <0x1f4>;
						charging_current = <0x4b0>;
					};

					current_group_12 {
						cable_number = <0x01 0x04 0x1e>;
						input_current = <0x1db>;
						charging_current = <0x226>;
					};

					current_group_13 {
						cable_number = <0x22>;
						input_current = <0x4b0>;
						charging_current = <0x92e>;
					};
				};
			};
		};
	};

	fragment@0 {
		target = <0xffffffff>;

		__overlay__ {
			os-type = "sensorhub/shub_nacho_a21s.bin";
		};
	};

	fragment@1 {
		target = <0xffffffff>;

		__overlay__ {
			ssp-acc-position = <0x04>;
			ssp-mag-position = <0x04>;
			ssp-prox-thresh = <0x190012c>;
			ssp-prox-mode-thresh = <0x190012d>;
			ssp-prox-setting-thresh = <0x1900082>;
			ssp-mag-array = [00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00];
		};
	};

	fragment@2 {
		target = <0xffffffff>;

		__overlay__ {
			ssp-mag-position = <0x00>;
			ssp-mag-array = [ea 52 7f 3f 6d 15 ff 45 d5 36 98 3c 6f a4 ff f9 02 a8 21 68 c1 fc 3d 56 08 b8 3c];
			ssp-mag-check-nfc = <0xffffffff 0x04 0x00>;
			ssp-mag-nfc-array = [8b 58 00 0d 4d 6c 01 82 d0 36 ef 05 8f 1c fc e8 05 bb f9 23 bd 00 29 af 08 4d d6];
		};
	};

	fragment@3 {
		target = <0xffffffff>;

		__overlay__ {
			#address-cells = <0x01>;
			#size-cells = <0x00>;
			status = "okay";

			s2mpb03_pmic@56 {
				compatible = "samsung,s2mpb03pmic";
				reg = <0x56>;
				s2mpb03,wakeup;

				regulators {

					s2mpb03-ldo1 {
						regulator-name = "CAM0_VLDO1";
						regulator-min-microvolt = <0x100590>;
						regulator-max-microvolt = <0x100590>;
						phandle = <0x3c>;
					};

					s2mpb03-ldo2 {
						regulator-name = "CAM0_VLDO2";
						regulator-min-microvolt = <0x10c8e0>;
						regulator-max-microvolt = <0x10c8e0>;
						phandle = <0x3f>;
					};

					s2mpb03-ldo3 {
						regulator-name = "CAM0_VLDO3";
						regulator-min-microvolt = <0x1b7740>;
						regulator-max-microvolt = <0x1b7740>;
						phandle = <0x3d>;
					};

					s2mpb03-ldo4 {
						regulator-name = "CAM0_VLDO4";
						regulator-min-microvolt = <0x124f80>;
						regulator-max-microvolt = <0x124f80>;
						phandle = <0x43>;
					};

					s2mpb03-ldo5 {
						regulator-name = "CAM0_VLDO5";
						regulator-min-microvolt = <0x2ab980>;
						regulator-max-microvolt = <0x2ab980>;
						phandle = <0x42>;
					};

					s2mpb03-ldo6 {
						regulator-name = "CAM0_VLDO6";
						regulator-min-microvolt = <0x2ab980>;
						regulat
